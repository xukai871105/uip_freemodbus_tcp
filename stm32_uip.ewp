# IAR project stm32_uip.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: CMSIS; StdPeriph_Driver\inc; User; uIP-1.0\uip; hello-world; FreeModbus\modbus\include; FreeModbus\modbus\tcp; FreeModbus\port
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32-uIP.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FreeModbus/modbus
    FreeModbus/modbus/: mb.c
  group FreeModbus/modbus/functions
    FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FreeModbus/modbus/include
    FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group FreeModbus/modbus/tcp
    FreeModbus/modbus/tcp/: mbtcp.c mbtcp.h
  group FreeModbus/port
    FreeModbus/port/: port.h portevent.c portother.c porttcp.c
  group StartUp
    StartUp/: startup_stm32f10x_hd.s
  group Stdperiph_Driver
    StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group uIP
    uIP-1.0/uip/: psock.c uip-fw.c uip-neighbor.c uip.c uip_arp.c uiplib.c
  group User
    User/: bsp_spi1.c bsp_spi1.h bsp_usart.c bsp_usart.h enc28j60.c enc28j60.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h tapdev.c tapdev.h timer.c timer.h uip-conf.h uip_modbus.h
